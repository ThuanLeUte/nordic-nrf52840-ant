# Keil uVision project ant_usb_dongle.uvprojx, settings and files
target nrf52840_xxaa (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_SPARKFUN_NRF52840_MINI CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF52_PAN_74 S212 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: .\config;..\sdk\nRF5_SDK_17.0.2_d674dde\components;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_advertising;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_dtm;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_link_ctx_manager;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_racp;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_ancs_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_ans_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_bas;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_bas_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_cscs;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_cts_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_dfu;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_dis;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_gls;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_hids;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_hrs;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_hrs_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_hts;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_ias;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_ias_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_lbs;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_lbs_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_lls;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_nus;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_nus_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_rscs;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_rscs_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_tps;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\common;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\nrf_ble_gatt;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\nrf_ble_qwr;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\peer_manager;..\sdk\nRF5_SDK_17.0.2_d674dde\components\boards;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\atomic;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\atomic_fifo;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\atomic_flags;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\balloc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\bootloader\ble_dfu;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\bsp;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\button;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\cli;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\crc16;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\crc32;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\crypto;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\csense;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\csense_drv;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\delay;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\ecc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\experimental_section_vars;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\experimental_task_manager;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\fds;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\fifo;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\fstorage;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\gfx;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\gpiote;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\hardfault;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\hardfault\nrf52;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\hci;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\led_softblink;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\log;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\log\src;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\low_power_pwm;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\mem_manager;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\memobj;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\mpu;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\mutex;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\pwm;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\pwr_mgmt;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\queue;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\ringbuf;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\scheduler;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\sdcard;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\slip;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\sortlist;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\spi_mngr;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\stack_guard;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\strerror;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\svc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\timer;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\twi_mngr;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\twi_sensor;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\uart;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\audio;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\cdc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\cdc\acm;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\hid;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\hid\generic;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\hid\kbd;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\hid\mouse;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\msc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\util;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\ac_rec;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_oob_advdata;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_pair_lib;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_pair_msg;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\common;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\ep_oob_rec;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\hs_rec;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\le_oob_rec;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\generic\message;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\generic\record;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\launchapp;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\parser\message;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\parser\record;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\text;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\uri;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\platform;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t2t_lib;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t2t_parser;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t4t_lib;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t4t_parser\apdu;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t4t_parser\cc_file;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t4t_parser\hl_detection_procedure;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t4t_parser\tlv;..\sdk\nRF5_SDK_17.0.2_d674dde\components\softdevice\common;..\sdk\nRF5_SDK_17.0.2_d674dde\components\softdevice\s212\headers\nrf52;..\sdk\nRF5_SDK_17.0.2_d674dde\components\softdevice\s212\headers;..\sdk\nRF5_SDK_17.0.2_d674dde\external\fprintf;..\sdk\nRF5_SDK_17.0.2_d674dde\external\segger_rtt;..\sdk\nRF5_SDK_17.0.2_d674dde\external\utf_converter;..\sdk\nRF5_SDK_17.0.2_d674dde\integration\nrfx;..\sdk\nRF5_SDK_17.0.2_d674dde\integration\nrfx\legacy;..\sdk\nRF5_SDK_17.0.2_d674dde\modules\nrfx;..\sdk\nRF5_SDK_17.0.2_d674dde\modules\nrfx\drivers\include;..\sdk\nRF5_SDK_17.0.2_d674dde\modules\nrfx\hal;..\config;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_channel_config;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_key_manager;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_key_manager\config;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_hrm;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_hrm\pages;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_hrm\simulator;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_hrm\utils;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_state_indicator;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\sensorsim;..\sdk\nRF5_SDK_17.0.2_d674dde\external\freertos\config;..\sdk\nRF5_SDK_17.0.2_d674dde\external\freertos\portable\ARM\nrf52;..\sdk\nRF5_SDK_17.0.2_d674dde\external\freertos\portable\CMSIS\nrf52;..\sdk\nRF5_SDK_17.0.2_d674dde\external\freertos\source\include;..\..\..\user;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_bpwr\utils;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_bpwr;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_bpwr\pages;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_bpwr\simulator;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_common\pages;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_bsc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_bsc\pages;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ant\ant_profiles\ant_bsc\utils
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: .\config;..\sdk\nRF5_SDK_17.0.2_d674dde\components;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_advertising;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_dtm;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_link_ctx_manager;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_racp;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_ancs_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_ans_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_bas;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_bas_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_cscs;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_cts_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_dfu;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_dis;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_gls;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_hids;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_hrs;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_hrs_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_hts;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_ias;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_ias_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_lbs;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_lbs_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_lls;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_nus;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_nus_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_rscs;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_rscs_c;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\ble_services\ble_tps;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\common;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\nrf_ble_gatt;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\nrf_ble_qwr;..\sdk\nRF5_SDK_17.0.2_d674dde\components\ble\peer_manager;..\sdk\nRF5_SDK_17.0.2_d674dde\components\boards;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\atomic;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\atomic_fifo;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\atomic_flags;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\balloc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\bootloader\ble_dfu;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\bsp;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\button;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\cli;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\crc16;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\crc32;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\crypto;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\csense;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\csense_drv;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\delay;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\ecc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\experimental_section_vars;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\experimental_task_manager;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\fds;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\fifo;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\fstorage;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\gfx;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\gpiote;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\hardfault;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\hardfault\nrf52;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\hci;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\led_softblink;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\log;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\log\src;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\low_power_pwm;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\mem_manager;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\memobj;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\mpu;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\mutex;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\pwm;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\pwr_mgmt;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\queue;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\ringbuf;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\scheduler;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\sdcard;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\slip;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\sortlist;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\spi_mngr;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\stack_guard;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\strerror;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\svc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\timer;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\twi_mngr;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\twi_sensor;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\uart;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\audio;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\cdc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\cdc\acm;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\hid;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\hid\generic;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\hid\kbd;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\hid\mouse;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\usbd\class\msc;..\sdk\nRF5_SDK_17.0.2_d674dde\components\libraries\util;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\ac_rec;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_oob_advdata;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_pair_lib;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\ble_pair_msg;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\common;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\ep_oob_rec;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\hs_rec;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\connection_handover\le_oob_rec;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\generic\message;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\generic\record;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\launchapp;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\parser\message;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\parser\record;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\text;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\ndef\uri;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\platform;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t2t_lib;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t2t_parser;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t4t_lib;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t4t_parser\apdu;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t4t_parser\cc_file;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t4t_parser\hl_detection_procedure;..\sdk\nRF5_SDK_17.0.2_d674dde\components\nfc\t4t_parser\tlv;..\sdk\nRF5_SDK_17.0.2_d674dde\components\softdevice\common;..\sdk\nRF5_SDK_17.0.2_d674dde\components\softdevice\s140\headers;..\sdk\nRF5_SDK_17.0.2_d674dde\components\softdevice\s140\headers\nrf52;..\sdk\nRF5_SDK_17.0.2_d674dde\external\fprintf;..\sdk\nRF5_SDK_17.0.2_d674dde\external\segger_rtt;..\sdk\nRF5_SDK_17.0.2_d674dde\external\utf_converter;..\sdk\nRF5_SDK_17.0.2_d674dde\integration\nrfx;..\sdk\nRF5_SDK_17.0.2_d674dde\integration\nrfx\legacy;..\sdk\nRF5_SDK_17.0.2_d674dde\modules\nrfx;..\sdk\nRF5_SDK_17.0.2_d674dde\modules\nrfx\drivers\include;..\sdk\nRF5_SDK_17.0.2_d674dde\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x12000 size 0x6e000
  memory RVCT9: RAM 0x20000b80 size 0xf480
  link misc: --diag_suppress 6330
  group Application
    ./user/: main.c app_ant.c app_usb.c ant_msg_builder.c bsp_usb_ant.c
    ./config/: sdk_config.h
  group Board Definition
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/boards/: boards.c
  group Board Support
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/bsp/: bsp.c
  group UTF8/UTF16 converter
    ../sdk/nRF5_SDK_17.0.2_d674dde/external/utf_converter/: utf.c
  group nRF_Drivers
    ../sdk/nRF5_SDK_17.0.2_d674dde/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_uart.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/modules/nrfx/soc/: nrfx_atomic.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_systick.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/button/: app_button.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/fifo/: app_fifo.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/scheduler/: app_scheduler.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/hardfault/: hardfault_implementation.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/atomic_flags/: nrf_atflags.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/atomic/: nrf_atomic.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/balloc/: nrf_balloc.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/memobj/: nrf_memobj.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/ringbuf/: nrf_ringbuf.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/sortlist/: nrf_sortlist.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/strerror/: nrf_strerror.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/sensorsim/: sensorsim.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/timer/: app_timer_freertos.c
  group nRF_Log
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../sdk/nRF5_SDK_17.0.2_d674dde/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/softdevice/common/: nrf_sdh.c nrf_sdh_ant.c
  group nRF_ANT
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_channel_config/: ant_channel_config.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_key_manager/: ant_key_manager.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_profiles/ant_hrm/: ant_hrm.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_profiles/ant_hrm/simulator/: ant_hrm_simulator.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_profiles/ant_hrm/pages/: ant_hrm_page_0.c ant_hrm_page_1.c ant_hrm_page_2.c ant_hrm_page_3.c ant_hrm_page_4.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_state_indicator/: ant_state_indicator.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_profiles/ant_bpwr/: ant_bpwr.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_profiles/ant_bpwr/pages/: ant_bpwr_common_data.c ant_bpwr_page_1.c ant_bpwr_page_16.c ant_bpwr_page_17.c ant_bpwr_page_18.c ant_bpwr_page_torque.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_profiles/ant_bpwr/simulator/: ant_bpwr_simulator.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_profiles/ant_common/pages/: ant_common_page_80.c ant_common_page_81.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_profiles/ant_bsc/: ant_bsc.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_profiles/ant_bsc/pages/: ant_bsc_combined_page_0.c ant_bsc_page_0.c ant_bsc_page_1.c ant_bsc_page_2.c ant_bsc_page_4.c ant_bsc_page_5.c ant_bsc_page_3.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/components/ant/ant_search_config/: ant_search_config.c
  group Third Parties
    ../sdk/nRF5_SDK_17.0.2_d674dde/external/freertos/source/: croutine.c list.c timers.c tasks.c stream_buffer.c queue.c event_groups.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/external/freertos/source/portable/MemMang/: heap_1.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
    ../sdk/nRF5_SDK_17.0.2_d674dde/external/freertos/portable/ARM/nrf52/: port.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
